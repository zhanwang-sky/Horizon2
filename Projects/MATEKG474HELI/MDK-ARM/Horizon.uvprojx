# Keil uVision project Horizon.uvprojx, settings and files
target Horizon (6220000::V6.22::ARMCLANG)
  device: STM32G474CEUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Horizon +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,USE_FreeRTOS,UNIT_TEST,DEBUG
  c include: ..\..\..\Codebase\Applications\rx;..\..\..\Codebase\AL\STM32\Inc;..\..\..\Codebase\FreeRTOS\include;..\..\..\Codebase\FreeRTOS\portable\GCC\ARM_CM4F;..\..\..\Codebase\BSP\MATEKG474HELI\Inc;..\..\..\Codebase\Drivers\CMSIS\Core\Include;..\..\..\Codebase\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\..\Codebase\Drivers\STM32G4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    ../../../Codebase/Applications/: main.c
    ../../../Codebase/Applications/flight/: fc.c
    ../../../Codebase/Applications/rx/: sbus.c sbus_receiver.c
    ../../../Codebase/Applications/test/: unit_test.c
  group AL
    ../../../Codebase/AL/STM32/Src/: al.c al_analog.c al_exti.c al_gpio.c al_i2c.c al_pwm.c al_spi.c al_uart.c
  group FreeRTOS
    ../../../Codebase/FreeRTOS/: list.c queue.c tasks.c
    ../../../Codebase/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../../../Codebase/FreeRTOS/portable/MemMang/: heap_1.c
  group BSP
    ../../../Codebase/BSP/MATEKG474HELI/Src/: matekg474heli_bsp.c startup_stm32g474xx.s stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c stm32g4xx_it.c
  group Drivers/CMSIS
    ../../../Codebase/Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Drivers/HAL
    ../../../Codebase/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
