# Keil uVision project Horizon2.uvprojx, settings and files
target Horizon2 (6190000::V6.19::ARMCLANG)
  device: STM32F722RETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Horizon2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F722xx
  c include: ..\..\..\Codebase\BSP\MAMBAF722_2022B\Inc;..\..\..\Codebase\Drivers\CMSIS\Core\Include;..\..\..\Codebase\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\Codebase\Drivers\STM32F7xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Application
    ../../../Codebase/Application/: main.c
  group BSP
    ../../../Codebase/BSP/MAMBAF722_2022B/Src/: mambaf722_2022b_bsp.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Drivers/CMSIS
    ../../../Codebase/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f722xx.s
    ../../../Codebase/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/HAL
    ../../../Codebase/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
